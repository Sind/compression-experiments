# IAR project rail_efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG1P132F256GM48 SiliconLaboratories EFR32FG1P132F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG1P132F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4252A
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/CMSIS/include; ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/Device/SiliconLabs/EFR32FG1P/Include; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\emdrv\rtcdrv\inc; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\emdrv\ustimer\inc; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\emdrv\gpiointerrupt\inc; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\emdrv\common\inc; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\emlib\inc; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\kits\common\bsp; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\kits\common\drivers; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\hal\efr32; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\hal; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\rail_lib\common; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\rail_lib\protocol\ieee802154; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\rail_lib\protocol\ble; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\rail_lib\chip\efr32; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\meta-inf; ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\submodules\kits\EFR32FG1_BRD4252A\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rail.bin
  ILINK.IlinkOutputFile: rail.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Apps\SimplicityStudio_v4\developer\stacks\rail\v1.3.1.0\autogen\librail_release\librail_efr32_iar_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG1P132F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4252A
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/hal/efr32/: hal_efr.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/hal/: hal_common.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/emdrv/ustimer/src/: ustimer.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/kits/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/kits/common/drivers/: dmactrl.c retargetio.c retargetserial.c udelay.c
    ./: rail-callback-stubs.c rail-callbacks.c rail_config.c
  group CMSIS
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/Device/SiliconLabs/EFR32FG1P/Source/IAR/: startup_efr32fg1p.s
    ../../../../Apps/SimplicityStudio_v4/developer/stacks/rail/v1.3.1.0/submodules/Device/SiliconLabs/EFR32FG1P/Source/: system_efr32fg1p.c
